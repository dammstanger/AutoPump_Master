/******************** (C) COPYRIGHT 2016 DammStanger *****************************************
**--------------文件信息----------------------------------------------------------
 * 文件名	：Transmit.c
 * 描	述	：RTU通信协议,从机端
 *            
 * 实验平台	：自控水泵V1.0  60S2 11.0592MHz
 * 硬件连接	：
 * 版 	本	：V0.1.160124
 * 从属关系	：PoolAuto
 * 库版本	：无
 * 创建时间	：2016.1.24
 * 最后编辑	：2016.2.14
 **-------------------------------------------------------------------------------

 * 作	者	：Damm Stanger
 * 邮	箱	：dammstanger@qq.com
**********************************************************************************************/

/****************************包含头文件*******************************************/


/****************************包含头文件*******************************************/
#include "Transmit.h"
#include "globaldefine.h"
#include "SI4432.h"

/****************************宏定义***********************************************/

/****************************变量声明*********************************************/

/****************************变量定义*********************************************/
uchar Revbuf[PAG_REVSIZE] = {0};
uchar Sendbuf[PAG_SEDSIZE] = {0};

uchar Trans_RevPakFin = 0;
uchar Trans_RevPakErr = 0;
PAG_DATA *pag_data=&sensor_data;

/****************************函数声明*********************************************/

/********************************************************************************
 * 函数名：PakRev_OverTimeDeal()
 * 描述  ：
 * 输入  ：-		    	
 * 返回  ：inttype
 * 调用  ：-
 ********************************************************************************/
void PakRev_OverTimeDeal()
{
	if(Trans_RevPakFin!=0)
	{
		;
	}
		
}

/********************************************************************************
 * 函数名：PakRev_BufHandle()
 * 描述  ：
 * 输入  ：-		    	
 * 返回  ：inttype
 * 调用  ：-
 ********************************************************************************/
uchar PakRev_BufHandle(uchar dat)
{
	return dat;
}

/********************************************************************************
 * 函数名：Pak_Handle
 * 描述  ：
 * 输入  ：-		    	
 * 返回  ：- 
 * 调用  ：外部调用
 ********************************************************************************/
uchar Pak_Handle(void)
{
	if(Is_DATA_Cmd_Pkg())
	{
		DATA_Cmd_Handle();
		DATA_Cmd_ACK();
		return 1;
	}
	else if(Is_DATA_Ack_Pkg())
	{	
		DATA_Cmd_Handle();
		return 2;
	}
	return 0;
}


/******************* (C) COPYRIGHT 2016 DammStanger *****END OF FILE************/

