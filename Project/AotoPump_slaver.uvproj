# Keil uVision project AotoPump_slaver.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: AutoPumpV2_master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\BSP;..\HW;..\User
  group HW
    ../HW/: SI4432.c DS3231.c YXD19264D_51.c Key.c
  group BSP
    ../BSP/: SPI_51.c UART_51.c IIC_soft_51.c Time.c EEPROM_51.c
  group APP
    ../APP/: Transmit.c Sensor.c LCD_GUI.c
  group USER
    ../User/: main.c
  group README
    ../: readme.txt
